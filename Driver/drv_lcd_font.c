#include "drv_lcd_font.h"

static void Font_Copy(uint8_t dst[DRV_LCD_FONT_5X7_WIDTH],
                      uint8_t a, uint8_t b, uint8_t c, uint8_t d, uint8_t e)
{
    dst[0] = a;
    dst[1] = b;
    dst[2] = c;
    dst[3] = d;
    dst[4] = e;
}

void Drv_LcdFont_GetGlyph5x7(char ch, uint8_t glyph[DRV_LCD_FONT_5X7_WIDTH])
{
    if (glyph == 0) {
        return;
    }

    if ((ch >= 'a') && (ch <= 'z')) {
        ch = (char)(ch - 'a' + 'A');
    }

    switch (ch) {
        case '0': Font_Copy(glyph, 0x3E, 0x51, 0x49, 0x45, 0x3E); break;
        case '1': Font_Copy(glyph, 0x00, 0x42, 0x7F, 0x40, 0x00); break;
        case '2': Font_Copy(glyph, 0x42, 0x61, 0x51, 0x49, 0x46); break;
        case '3': Font_Copy(glyph, 0x21, 0x41, 0x45, 0x4B, 0x31); break;
        case '4': Font_Copy(glyph, 0x18, 0x14, 0x12, 0x7F, 0x10); break;
        case '5': Font_Copy(glyph, 0x27, 0x45, 0x45, 0x45, 0x39); break;
        case '6': Font_Copy(glyph, 0x3C, 0x4A, 0x49, 0x49, 0x30); break;
        case '7': Font_Copy(glyph, 0x01, 0x71, 0x09, 0x05, 0x03); break;
        case '8': Font_Copy(glyph, 0x36, 0x49, 0x49, 0x49, 0x36); break;
        case '9': Font_Copy(glyph, 0x06, 0x49, 0x49, 0x29, 0x1E); break;
        case 'A': Font_Copy(glyph, 0x7E, 0x11, 0x11, 0x11, 0x7E); break;
        case 'B': Font_Copy(glyph, 0x7F, 0x49, 0x49, 0x49, 0x36); break;
        case 'C': Font_Copy(glyph, 0x3E, 0x41, 0x41, 0x41, 0x22); break;
        case 'D': Font_Copy(glyph, 0x7F, 0x41, 0x41, 0x22, 0x1C); break;
        case 'E': Font_Copy(glyph, 0x7F, 0x49, 0x49, 0x49, 0x41); break;
        case 'F': Font_Copy(glyph, 0x7F, 0x09, 0x09, 0x09, 0x01); break;
        case 'G': Font_Copy(glyph, 0x3E, 0x41, 0x49, 0x49, 0x7A); break;
        case 'H': Font_Copy(glyph, 0x7F, 0x08, 0x08, 0x08, 0x7F); break;
        case 'I': Font_Copy(glyph, 0x00, 0x41, 0x7F, 0x41, 0x00); break;
        case 'J': Font_Copy(glyph, 0x20, 0x40, 0x41, 0x3F, 0x01); break;
        case 'K': Font_Copy(glyph, 0x7F, 0x08, 0x14, 0x22, 0x41); break;
        case 'L': Font_Copy(glyph, 0x7F, 0x40, 0x40, 0x40, 0x40); break;
        case 'M': Font_Copy(glyph, 0x7F, 0x02, 0x0C, 0x02, 0x7F); break;
        case 'N': Font_Copy(glyph, 0x7F, 0x04, 0x08, 0x10, 0x7F); break;
        case 'O': Font_Copy(glyph, 0x3E, 0x41, 0x41, 0x41, 0x3E); break;
        case 'P': Font_Copy(glyph, 0x7F, 0x09, 0x09, 0x09, 0x06); break;
        case 'Q': Font_Copy(glyph, 0x3E, 0x41, 0x51, 0x21, 0x5E); break;
        case 'R': Font_Copy(glyph, 0x7F, 0x09, 0x19, 0x29, 0x46); break;
        case 'S': Font_Copy(glyph, 0x46, 0x49, 0x49, 0x49, 0x31); break;
        case 'T': Font_Copy(glyph, 0x01, 0x01, 0x7F, 0x01, 0x01); break;
        case 'U': Font_Copy(glyph, 0x3F, 0x40, 0x40, 0x40, 0x3F); break;
        case 'V': Font_Copy(glyph, 0x1F, 0x20, 0x40, 0x20, 0x1F); break;
        case 'W': Font_Copy(glyph, 0x7F, 0x20, 0x18, 0x20, 0x7F); break;
        case 'X': Font_Copy(glyph, 0x63, 0x14, 0x08, 0x14, 0x63); break;
        case 'Y': Font_Copy(glyph, 0x07, 0x08, 0x70, 0x08, 0x07); break;
        case 'Z': Font_Copy(glyph, 0x61, 0x51, 0x49, 0x45, 0x43); break;
        case '-': Font_Copy(glyph, 0x08, 0x08, 0x08, 0x08, 0x08); break;
        case '_': Font_Copy(glyph, 0x40, 0x40, 0x40, 0x40, 0x40); break;
        case ':': Font_Copy(glyph, 0x00, 0x36, 0x36, 0x00, 0x00); break;
        case '.': Font_Copy(glyph, 0x00, 0x60, 0x60, 0x00, 0x00); break;
        case '/': Font_Copy(glyph, 0x20, 0x10, 0x08, 0x04, 0x02); break;
        case '+': Font_Copy(glyph, 0x08, 0x08, 0x3E, 0x08, 0x08); break;
        case '%': Font_Copy(glyph, 0x23, 0x13, 0x08, 0x64, 0x62); break;
        case ' ': Font_Copy(glyph, 0x00, 0x00, 0x00, 0x00, 0x00); break;
        default:  Font_Copy(glyph, 0x02, 0x01, 0x51, 0x09, 0x06); break;
    }
}
