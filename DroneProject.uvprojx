# Keil uVision project DroneProject.uvprojx, settings and files
target Drone (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DroneProject
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\libraries\CMSIS\Device\ST\STM32F4xx\Include;.\libraries\CMSIS\Include;.\libraries\STM32F4xx_StdPeriph_Driver\inc;.\user;.\user\led;.\System;.\Middleware;.\BSP;.\Driver;.\Algorithm;.\VL53L1_core;.\VL53L1_platform;.\APP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./libraries/CMSIS/Device/ST/STM32F4xx/Include/: stm32f4xx.h
  group StdPeriph_Driver
    ./libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ./libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group System
    ./System/: Delay.c Delay.h bsp_timer.h bsp_timer.c
  group User
    ./user/: main.c stm32f4xx_it.c
    ./user/led/: bsp_led.c bsp_led.h
  group Middleware
    ./Middleware/: task_scheduler.h task_scheduler.c
  group BSP
    ./BSP/: bsp_uart.h bsp_uart.c bsp_i2c.h bsp_i2c.c bsp_spi.h bsp_spi.c bsp_pwm.c bsp_pwm.h bsp_rc_pwm.c bsp_rc_pwm.h bsp_uart3.c bsp_uart3.h
  group Driver
    ./Driver/: k210_protocol.c k210_protocol.h mpu9250.h mpu9250.c bmp280.h bmp280.c mpu9250_calib.h mpu9250_calib.c VL53L1X.h VL53L1X.c pmw3901.h pmw3901.c
  group Algorithm
    ./Algorithm/: ahrs_fusion.c ahrs_fusion.h altitude_ctrl.c altitude_ctrl.h attitude_ctrl.c attitude_ctrl.h lowpass.c lowpass.h mahony.c mahony.h pid.c pid.h position_ctrl.c position_ctrl.h quaternion.c quaternion.h
  group VL53L1_core
    ./VL53L1_core/: vl53l1_api.c vl53l1_api.h vl53l1_api_calibration.c vl53l1_api_calibration.h vl53l1_api_core.c vl53l1_api_core.h vl53l1_api_debug.c vl53l1_api_debug.h vl53l1_api_preset_modes.c vl53l1_api_preset_modes.h vl53l1_api_strings.c vl53l1_api_strings.h vl53l1_core.c vl53l1_core.h vl53l1_core_support.c vl53l1_core_support.h vl53l1_def.h vl53l1_error_codes.h vl53l1_error_exceptions.h vl53l1_error_strings.c vl53l1_error_strings.h vl53l1_ll_def.h vl53l1_ll_device.h vl53l1_nvm_map.h vl53l1_preset_setup.h vl53l1_register_funcs.c vl53l1_register_funcs.h vl53l1_register_map.h vl53l1_register_settings.h vl53l1_register_structs.h vl53l1_silicon_core.c vl53l1_silicon_core.h vl53l1_tuning_parm_defaults.h vl53l1_wait.c vl53l1_wait.h
  group VL53L1_platform
    ./VL53L1_platform/: vl53l1_platform.c vl53l1_platform.h vl53l1_platform_init.c vl53l1_platform_init.h vl53l1_platform_ipp_imports.h vl53l1_platform_user_config.h vl53l1_platform_user_data.h vl53l1_platform_user_defines.h vl53l1_types.h
  group APP
    ./APP/: app_bmp280_task.c app_bmp280_task.h app_mpu_task.c app_mpu_task.h app_pmw3901_task.c app_pmw3901_task.h app_vl53l1x_task.c app_vl53l1x_task.h app_attitude_task.c app_attitude_task.h app_flight_data_task.c app_flight_data_task.h app_altitude_estimator_task.c app_altitude_estimator_task.h app_rate_test_task.c app_rate_test_task.h app_rc_task.c app_rc_task.h app_angle_test_task.c app_angle_test_task.h app_altitude_pid_task.c app_altitude_pid_task.h app_alt_hold_task.c app_alt_hold_task.h app_attitude_pid_task.c app_attitude_pid_task.h app_motor_mixer_task.c app_motor_mixer_task.h app_motor_output_task.c app_motor_output_task.h app_rc_command_task.c app_rc_command_task.h app_takeoff_tune.h
